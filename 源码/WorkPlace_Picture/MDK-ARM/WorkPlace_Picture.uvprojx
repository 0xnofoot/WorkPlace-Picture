# Keil uVision project WorkPlace_Picture.uvprojx, settings and files
target WorkPlace_Picture (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: STM32F767ZITx STMicroelectronics
  pack: Keil.STM32F7xx_DFP.2.11.0
  cpu: IRAM(0x20000000-0x2007FFFF) IROM(0x8000000-0x81FFFFF) CLOCK(12000000) FPU3(DFPU) CPUTYPE("Cortex-M7") ELITTLE
  output: WorkPlace_Picture +hex
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=3 v6LangP=3 wLevel=2
  c define: USE_HAL_DRIVER,STM32F767xx
  c include: ../Inc;                                            ../Drivers/STM32F7xx_HAL_Driver/Inc;                                            ../Drivers/STM32F7xx_HAL_Driver/Inc/Legacy;                                            ../Drivers/CMSIS/Device/ST/STM32F7xx/Include;                                            ../Drivers/CMSIS/Include;                                            ..\User
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x200000
  memory RVCT9: RAM 0x20000000 size 0x80000
  group Application/MDK-ARM
    ./: startup_stm32f767xx.s
  group User
    ../User/: Delay.c GUI.c Lcd_Driver.c State_Show.c Motor.c data_analysis.c cad.c cut.c openmv.c
  group Application/User
    ../Src/: main.c gpio.c spi.c tim.c usart.c stm32f7xx_it.c stm32f7xx_hal_msp.c
  group Drivers/STM32F7xx_HAL_Driver
    ../Drivers/STM32F7xx_HAL_Driver/Src/: stm32f7xx_hal_cortex.c stm32f7xx_hal_spi.c stm32f7xx_hal_spi_ex.c stm32f7xx_hal_tim.c stm32f7xx_hal_tim_ex.c stm32f7xx_hal_uart.c stm32f7xx_hal_rcc.c stm32f7xx_hal_rcc_ex.c stm32f7xx_hal_flash.c stm32f7xx_hal_flash_ex.c stm32f7xx_hal_gpio.c stm32f7xx_hal_dma.c stm32f7xx_hal_dma_ex.c stm32f7xx_hal_pwr.c stm32f7xx_hal_pwr_ex.c stm32f7xx_hal.c stm32f7xx_hal_i2c.c stm32f7xx_hal_i2c_ex.c stm32f7xx_hal_exti.c
  group Drivers/CMSIS
    ../Src/: system_stm32f7xx.c
software components: CMSIS:CORE 5.1.2
